# IAR project STM32-AliyunIoT-Paho.ewp, settings and files
configuration STM32-AliyunIoT-Paho (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R5ZI ST STM32L4R5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4R5xx; MSG_INFO; SAVE_RAM_MODE; USE_WIFI; MBEDTLS_CONFIG_FILE=<config_hmacsha1.h>
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/Components/hts221/; ..\Middlewares\Third_Party\mbedtls-2.16.0\include; ..\Middlewares\Third_Party\paho.mqtt.embedded-c-1.1.0\MQTTClient-C\src; ..\Middlewares\Third_Party\paho.mqtt.embedded-c-1.1.0\MQTTPacket\src; ..\Src\Common\inc; ..\Src\Ali; ..\rtthread; ..\rtthread\include; ..\finsh
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32-AliyunIoT-Paho.hex
  ILINK.IlinkOutputFile: STM32-AliyunIoT-Paho.out
  ILINK.IlinkIcfFile: stm32l4r5xx_flash_custom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/AliIoT
    ../Src/Ali/: Ali_iot_network_wrapper.c Ali_iotclient.c mqtt_msg_handler.c
  group Application/Common
    ../Src/Common/: flash_l4R.c iot_flash_config.c net.c net_tcp_wifi.c paho_timer.c wifi_net.c
  group Application/EWARM
    ./: startup_stm32l4r5xx.s
  group Application/User
    ../Src/: app_x-cube-mems1.c bh1750_i2c_drv.c custom_bus.c custom_mems_processor.c main.c oled.c stm32l4xx_hal_msp.c stm32l4xx_it.c Task.c
  group Application/wifi
    ../Src/: emw3080.c emw3080_io.c wifi.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group finsh
    ../finsh/: cmd.c msh.c shell.c
  group Middlewares/Mbedtls_v2.16
    ../Middlewares/Third_Party/mbedtls-2.16.0/library/: md.c md_wrap.c platform_util.c sha1.c
  group Middlewares/paho.mqtt.embedded-c/MQTTClient-C
    ../Middlewares/Third_Party/paho.mqtt.embedded-c-1.1.0/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/paho.mqtt.embedded-c/MQTTPacket
    ../Middlewares/Third_Party/paho.mqtt.embedded-c-1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group rttread
    ../rtthread/: board.c
    ../rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../rtthread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
